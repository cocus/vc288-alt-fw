<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm8.ewp</path>
    </project>
    <batchBuild />
</workspace>
