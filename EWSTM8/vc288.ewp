# IAR project vc288.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 2
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCDefines: _IAR_; STM8S003
  ICCSTM8.PreInclude: ..\src\config.h
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: vc288.hex
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 2
  OBJCOPY.OOCOutputFile: stm8.srec
  group src
    ../src/: adc.c adc.h clock.c clock.h config.h config_8s003.h display_7seg.c display_7seg.h eeprom.c eeprom.h gpio.h gpio_8s003.c main.c stm8.h stm8s_conf.h timer.c timer.h
